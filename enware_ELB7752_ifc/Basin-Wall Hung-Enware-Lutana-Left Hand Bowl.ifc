Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-06-26T16:09:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 16:09:37 2019 * Host: A2K_QLD_L056 * Database: C:\Users\danh\AppData\Local\Temp\{574B48F9-8189-48D6-A594-90469D2BDBE7}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 16:09:37 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 16:09:37 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 16:09:37 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: 1 x Taphole, 1 x Overflow, Basin-Wall Hung-Enware-Lutana-Left Hand Bowl:1 x Taphole, 1 x Overflow:249533
In: Ground Floor
Material: Metal-Chrome-Enware, Vitreous China-Enware-White
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: 1 x Taphole, 1 x Overflow
Constraints - Elevation: 0 mm; Host: Basic Wall : Double brick - 270
Dimensions - Area: 0.634994 m2; Volume: 0.0226685 m3
Identity Data - Mark: 24
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, 1 x Overflow; Family and Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, 1 x Overflow; Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, 1 x Overflow; Type Id: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, 1 x Overflow
Phasing - Phase Created: New Construction
Visibility - Ceramic Shroud: no; Mental Health Shroud: no; No Shroud: yes; Shroud Type Selector: 0
Constraints(Type) - Default Elevation: 900 mm
Dimensions(Type) - Depth_ANZRS: 445 mm; Height_ANZRS: 155 mm; Waste Diameter: 32 mm; Width_ANZRS: 770 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Nordic design wash basin featuring half-moon shape wash bowl and integrated shelf, raised rear edge and smooth rounded corner on bowl side. Ideal for residential aged care, health, independent living units, education, commercial and public places.; Manufacturer: Enware; Model: Lutana Basin 770 - Left Hand Bowl; ProductCode_ANZRS: ELB7762; Type Name: 1 x Taphole, 1 x Overflow; URL: https://www.enware.com.au/
Materials and Finishes(Type) - Material_ANZRS: Vitreous China-Enware-White; Waste: Metal-Chrome-Enware
Mechanical(Type) - WFU: 0
Other(Type) - Category: Plumbing Fixtures; Family Name: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl
Visibility(Type) - Triple Tap Hole: no; No Tap Hole: no; Single Tap Hole: yes; Tap Hole Selector: 1; Overflow: yes

# IfcFlowTerminal: 1 x Taphole, No Overflow, Basin-Wall Hung-Enware-Lutana-Left Hand Bowl:1 x Taphole, No Overflow:227168
In: Ground Floor
Material: Metal-Chrome-Enware, Vitreous China-Enware-White
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: 1 x Taphole, No Overflow
Constraints - Level: Level: Ground Floor; Elevation: 800 mm; Host: Basic Wall : Double brick - 270
Dimensions - Area: 0.633686 m2; Volume: 0.0226846 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Schedule Level: Level: Ground Floor; Family: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, No Overflow; Family and Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, No Overflow; Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, No Overflow; Type Id: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 1 x Taphole, No Overflow
Phasing - Phase Created: New Construction
Visibility - Ceramic Shroud: no; Mental Health Shroud: no; No Shroud: yes; Shroud Type Selector: 0
Constraints(Type) - Default Elevation: 900 mm
Dimensions(Type) - Depth_ANZRS: 445 mm; Height_ANZRS: 155 mm; Waste Diameter: 32 mm; Width_ANZRS: 770 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Nordic design wash basin featuring half-moon shape wash bowl and integrated shelf, raised rear edge and smooth rounded corner on bowl side. Ideal for residential aged care, health, independent living units, education, commercial and public places.; Manufacturer: Enware; Model: Lutana Basin 770 - Left Hand Bowl; ProductCode_ANZRS: ELB7762-100; Type Name: 1 x Taphole, No Overflow; URL: https://www.enware.com.au/
Materials and Finishes(Type) - Material_ANZRS: Vitreous China-Enware-White; Waste: Metal-Chrome-Enware
Mechanical(Type) - WFU: 0
Other(Type) - Category: Plumbing Fixtures; Family Name: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl
Visibility(Type) - Overflow: no; Triple Tap Hole: no; No Tap Hole: no; Single Tap Hole: yes; Tap Hole Selector: 1

# IfcFlowTerminal: 3 x Taphole, 1 x Overflow, Basin-Wall Hung-Enware-Lutana-Left Hand Bowl:3 x Taphole, 1 x Overflow:249832
In: Ground Floor
Material: Metal-Chrome-Enware, Vitreous China-Enware-White
Visibility(Type) - No Tap Hole: no; Single Tap Hole: yes; Tap Hole Selector: 2; Triple Tap Hole: yes; Overflow: yes
Other(Type) - Category: Plumbing Fixtures; Family Name: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: 3 x Taphole, 1 x Overflow
Constraints - Elevation: 0 mm; Host: Basic Wall : Double brick - 270
Dimensions - Area: 0.640274 m2; Volume: 0.0225761 m3
Identity Data - Mark: 25
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, 1 x Overflow; Family and Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, 1 x Overflow; Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, 1 x Overflow; Type Id: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, 1 x Overflow
Phasing - Phase Created: New Construction
Visibility - Ceramic Shroud: no; Mental Health Shroud: no; No Shroud: yes; Shroud Type Selector: 0
Constraints(Type) - Default Elevation: 900 mm
Dimensions(Type) - Depth_ANZRS: 445 mm; Height_ANZRS: 155 mm; Waste Diameter: 32 mm; Width_ANZRS: 770 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Nordic design wash basin featuring half-moon shape wash bowl and integrated shelf, raised rear edge and smooth rounded corner on bowl side. Ideal for residential aged care, health, independent living units, education, commercial and public places.; Manufacturer: Enware; Model: Lutana Basin 770 - Left Hand Bowl; ProductCode_ANZRS: ELB776222; Type Name: 3 x Taphole, 1 x Overflow; URL: https://www.enware.com.au/
Materials and Finishes(Type) - Material_ANZRS: Vitreous China-Enware-White; Waste: Metal-Chrome-Enware
Mechanical(Type) - WFU: 0

# IfcFlowTerminal: 3 x Taphole, No Overflow, Basin-Wall Hung-Enware-Lutana-Left Hand Bowl:3 x Taphole, No Overflow:249466
In: Ground Floor
Material: Metal-Chrome-Enware, Vitreous China-Enware-White
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: 3 x Taphole, No Overflow
Constraints - Elevation: 0 mm; Host: Basic Wall : Double brick - 270
Dimensions - Area: 0.638966 m2; Volume: 0.0225922 m3
Identity Data - Mark: 23
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, No Overflow; Family and Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, No Overflow; Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, No Overflow; Type Id: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: 3 x Taphole, No Overflow
Phasing - Phase Created: New Construction
Visibility - Ceramic Shroud: no; Mental Health Shroud: no; No Shroud: yes; Shroud Type Selector: 0
Constraints(Type) - Default Elevation: 900 mm
Dimensions(Type) - Depth_ANZRS: 445 mm; Height_ANZRS: 155 mm; Waste Diameter: 32 mm; Width_ANZRS: 770 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Nordic design wash basin featuring half-moon shape wash bowl and integrated shelf, raised rear edge and smooth rounded corner on bowl side. Ideal for residential aged care, health, independent living units, education, commercial and public places.; Manufacturer: Enware; Model: Lutana Basin 770 - Left Hand Bowl; ProductCode_ANZRS: ELB776222-100; Type Name: 3 x Taphole, No Overflow; URL: https://www.enware.com.au/
Materials and Finishes(Type) - Material_ANZRS: Vitreous China-Enware-White; Waste: Metal-Chrome-Enware
Mechanical(Type) - WFU: 0
Other(Type) - Category: Plumbing Fixtures; Family Name: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl
Visibility(Type) - Overflow: no; No Tap Hole: no; Single Tap Hole: yes; Tap Hole Selector: 2; Triple Tap Hole: yes

# IfcFlowTerminal: No Taphole, No Overflow, Basin-Wall Hung-Enware-Lutana-Left Hand Bowl:No Taphole, No Overflow:206533
In: Ground Floor
Material: Metal-Chrome-Enware, Vitreous China-Enware-White
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: No Taphole, No Overflow
Constraints - Elevation: 800 mm; Host: Basic Wall : Double brick - 270; Level: Level: Ground Floor
Dimensions - Area: 0.631046 m2; Volume: 0.0227308 m3
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: No Taphole, No Overflow; Family and Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: No Taphole, No Overflow; Schedule Level: Level: Ground Floor; Type: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: No Taphole, No Overflow; Type Id: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl: No Taphole, No Overflow
Phasing - Phase Created: New Construction
Visibility - Ceramic Shroud: no; Mental Health Shroud: no; No Shroud: yes; Shroud Type Selector: 0
Constraints(Type) - Default Elevation: 900 mm
Dimensions(Type) - Depth_ANZRS: 445 mm; Height_ANZRS: 155 mm; Waste Diameter: 32 mm; Width_ANZRS: 770 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Nordic design wash basin featuring half-moon shape wash bowl and integrated shelf, raised rear edge and smooth rounded corner on bowl side. Ideal for residential aged care, health, independent living units, education, commercial and public places.; Manufacturer: Enware; Model: Lutana Basin 770 - Left Hand Bowl; ProductCode_ANZRS: ELB7760-100; Type Name: No Taphole, No Overflow; URL: https://www.enware.com.au/
Materials and Finishes(Type) - Material_ANZRS: Vitreous China-Enware-White; Waste: Metal-Chrome-Enware
Mechanical(Type) - WFU: 0
Other(Type) - Category: Plumbing Fixtures; Family Name: Basin-Wall Hung-Enware-Lutana-Left Hand Bowl
Visibility(Type) - No Tap Hole: yes; Overflow: no; Single Tap Hole: no; Tap Hole Selector: 0; Triple Tap Hole: no
